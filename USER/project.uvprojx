# Keil uVision project project.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\USART1;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\AT24C02;..\HARDWARE\OLED;..\HARDWARE\SPI;..\HARDWARE\W25Q128;..\HARDWARE\DHT11;..\HARDWARE\WIFI;..\SYSTEM\ringbuffer;..\FreeRTOS\include;..\FreeRTOS\port;..\SYSTEM\oledmenu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c light.c adcdma.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/AT24C02/: at24c02.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SPI/: spi.c spihardware.c
    ../HARDWARE/W25Q128/: w25q.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/WIFI/: esp8266.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/ringbuffer/: ringbuffer.c
    ../SYSTEM/oledmenu/: oledmenu.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_spi.c
  group FreeRTOS/CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/PORT
    ../FreeRTOS/port/: heap_4.c port.c
